# Keil uVision project spi_advanced_kobialka.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: spi_advanced_kobialka +hex
  c flags: Optim=1
  c include: "../inc"
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group src
    ./: Startup.s main.c spi_lab.c timer.c command_decoder.c keyboard.c led.c servo.c string.c timer_interrupts.c uart.c zegar.c
  group inc
    ../KOBIALKA/arm_agh-master/archive/kobialka_12_wysylanie_lan_znakowych/: timer.h
    ./: spi_lab.h command_decoder.h keyboard.h led.h servo.h string.h timer_interrupts.h uart.h zegar.h
