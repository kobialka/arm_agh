# Keil uVision project Kobialka_12_Wysylanie_lancuchow_znakowych.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Kobialka_12_Wysylanie_lancuchow_znakowych +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s main.c uart.c string.c zegar.c timer_interrupts.c command_decoder.c servo.c led.c
